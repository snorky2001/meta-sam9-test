FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://defconfig"
#KERNEL_DEFCONFIG_var-som-mx6 = "${WORKDIR}/my_defconfig"
